Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 5f3fe6de-c8af-45ee-a3d4-3d2813c0f823, NumberOfSaves: 19], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Screw_VGZEvo_5140.ifc
Time: 2026-03-31T17:10:28
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcMechanicalFastener: Structural Connections : ROTHOB_Rothoblaas_Screw_VGZEvo : 05.6x140mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_C4EvoCoating
Type - General - Author: ROTHO BLAAS SRL; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/screws/screws-structures/vgz-evo; Revision: n/a; UniClass2015Code: Pr_20_29_76_75; UniClass2015Title: Self-tapping screws; UniClass2015Version: Products v1.30; Version: 1
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 5140
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_C4EvoCoating
Type - Dimensions - HeadDiameter_dk: 8 mm; HeadThickness: 7.2 mm; InnerHeadDiameter: 4 mm; InsertionLength_L: 140 mm; NominalDiameter_d1: 5.6 mm; ThreadDiameter_d2: 3.8 mm; ThreadLength_b: 130 mm; ThreadRadius: 1.9 mm; TipLength: 7 mm; UnderheadDiameter: 7.2 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: 05.6x140mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; BitType: 25; CECode: ETA-11/0030; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Fully threaded screw with cylindrical head; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Screw_VGZEvo; Features: Self-tapping screws for timber constructions; Finish: C4 EVO coating; Grade: n/a; ICC-ESCode: AC233 | AC257 ESR-4645; ICC-ESTitle: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 0.016 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: VGZEVO5140; ModelReference: n/a; Name: Screw; NominalDiameter: 5.6 mm; NominalHeight: n/a; NominalLength: 140 mm; NominalWidth: n/a; ReplacementCost: n/a; Shape: Cylindrical; Size: 5.6x140 mm; SustainabilityPerformance: n/a; UKCACode: UKTA-0836 22/6195; UKCATitle: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_ProductRequirements - Name: Screw
Pset_QuantityTakeOff - Reference: 05.6x140mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00000170687 m3
Other - Family: ROTHOB_Rothoblaas_Screw_VGZEvo; Family and Type: ROTHOB_Rothoblaas_Screw_VGZEvo: 05.6x140mm; Type: 05.6x140mm; Type Id: 1321331
